# Keil uVision project Mp3Decoder.uvprojx, settings and files
target Mp3Decoder (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Mp3Decoder +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\Application\inc;..\..\Libraries\FWLib\inc;..\..\Application\inc\MassStorage;..\..\Libraries\USBLib\inc;..\..\Application\src\MassStorage;..\..\Application\Helix;..\..\Application\Helix\real;..\..\Application\Helix\pub
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ../../Application/src/: diskio.c ff.c main.c start_config.c stm32f10x_it.c systick.c Mp3Convert.c
    ../../Application/src/MassStorage/: SpiFlash.c
  group START
    ./: cortexm3_macro.s stm32f10x_vector.s
  group LIB
    ../../Libraries/FWLib/src/: stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_dma.c
  group USBLib
    ../../Libraries/USBLib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group MassStorage
    ../../Application/src/MassStorage/: hw_config.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group Helix
    ../../Application/Helix/: mp3dec.c mp3tabs.c
    ../../Application/Helix/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c polyphase.c scalfact.c stproc.c subband.c trigtabs_fixpt.c
software components: CMSIS:CORE 5.0.1
